# IAR project board_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54114J256BD64_cm4; USB_STACK_BM
  ICCARM.CCIncludePath2: ..\app; ..\bsp; ..\csp; ..\fatfs\fatfs_0.11a\src; ..\usbd\usb_1.2.0\device; ..\usbd\usb_1.2.0\include; ..\usbd\usb_1.2.0\osa; ..\usbd\usb_1.2.0\usr_class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: board_test.srec
  ILINK.IlinkOutputFile: board_test.out
  ILINK.IlinkIcfFile: ../csp/iar/LPC54114J256_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app_adc.c app_dmic.c app_interrupt.c app_key.c app_led.c app_pct2075.c app_spiflash.c app_spiSD.c app_usbdmsc.c app_wm8904.c application.c
  group bsp
    ../bsp/: board.c clock_config.c pin_mux.c
  group csp
    ../csp/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_debug_console.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flashiap.c fsl_flexcomm.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2c_freertos.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mrt.c fsl_notifier.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_sbrk.c fsl_sctimer.c fsl_shell.c fsl_spi.c fsl_spi_dma.c fsl_spi_freertos.c fsl_usart.c fsl_usart_dma.c fsl_usart_freertos.c fsl_utick.c fsl_wwdt.c system_LPC54114_cm4.c
    ../csp/iar/: iar_lib_power.a startup_LPC54114_cm4.s
  group fat
    ../fatfs/fatfs_0.11a/src/: diskio.c ff.c
  group usb
    ../usbd/usb_1.2.0/usr_class/: usb_device_ch9.c usb_device_class.c usb_device_descriptor.c usb_device_msc.c usb_device_msc_ufi.c
    ../usbd/usb_1.2.0/device/: usb_device_dci.c usb_device_lpcip3511.c
    ../usbd/usb_1.2.0/osa/: usb_osa_bm.c
